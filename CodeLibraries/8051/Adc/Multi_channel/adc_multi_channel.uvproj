# Keil uVision project adc_multi_channel.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: adc_multi_channel +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: adc.c delay.c main.c lcd.c
  group Header
    ./: adc.h delay.h lcd.h stdutils.h
