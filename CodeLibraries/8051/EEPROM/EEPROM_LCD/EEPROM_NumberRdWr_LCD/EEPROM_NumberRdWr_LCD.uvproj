# Keil uVision project EEPROM_NumberRdWr_LCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: EEPROM_NumberRdWr_LCD +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c eeprom.c i2c.c lcd.c main.c
  group Header
    ./: delay.h eeprom.h i2c.h lcd.h stdutils.h
