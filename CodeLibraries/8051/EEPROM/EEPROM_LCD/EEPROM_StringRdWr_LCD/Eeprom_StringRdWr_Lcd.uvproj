# Keil uVision project Eeprom_StringRdWr_Lcd.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: Eeprom_StringRdWr_Lcd +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c eeprom.c i2c.c main.c lcd.c
  group Header Group
    ./: delay.h eeprom.h i2c.h lcd.h stdutils.h
