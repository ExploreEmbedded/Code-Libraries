# Keil uVision project Eeprom_StringRdWr_Uart.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: Eeprom_StringRdWr_Uart +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c eeprom.c i2c.c main.c uart.c
  group Header Group
    ./: delay.h eeprom.h i2c.h uart.h stdutils.h
