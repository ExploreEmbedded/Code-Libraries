# Keil uVision project rtc_on_lcd.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: rtc_on_lcd +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c i2c.c main.c lcd.c rtc.c
  group Header
    ./: delay.h i2c.h lcd.h rtc.h stdutils.h
