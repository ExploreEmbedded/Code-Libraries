# Keil uVision project RTC_ON_UART.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: RTC_ON_UART +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c i2c.c main.c uart.c rtc.c
  group Header Group
    ./: delay.h i2c.h uart.h rtc.h stdutils.h
